# Keil uVision project uCosII.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC89C51RC Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: uCosII +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c INCLUDES.H
    ./CPU/: OS_CPU_A.ASM
  group OSS
    ./OSS/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C uCOS_II.C uCOS_II.H
  group CPU
    ./CPU/: OS_CPU_C.C
    ./: OS_CFG.H OS_CPU.H
