# Keil uVision project uCosii_51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C58RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: uCOS-II +hex
  c flags: Optimize=8
  group user_app
    ./Source/: main.c
  group uCosii
    ./uCosii/: OS_CORE.C OS_CPU_C.C OS_MBOX.C OS_MEM.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C STARTUP.A51 OS_CPU_A.ASM
